# Keil uVision project hw01_bowling.uvprojx, settings and files
target Simulator (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.3.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: hw01_bowling
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group StartUp
    ./: startup_LPC17xx.s system_LPC17xx.c
  group Source Files
    ./: Serial.c Retarget.c main.c
target LPC1768 RAM (ARM-ADS)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.3.0
  cpu: as above
  output: Blinky
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: __USE_LCD __ADC_IRQ
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target LPC1768 Flash (ARM-ADS)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.3.0
  cpu: as above
  output: Blinky
  c flags: Optim=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
software components: CMSIS:CORE 5.0.2
